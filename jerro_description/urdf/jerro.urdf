Commit message: update pkg joint

File: jerro_description/urdf/jerro.urdf (robot description, URDF)
Before this commit: robot jerro, 8 links, 7 joints
Joints:
- joint base_link_to_servomotor: axis 0 1 0 -> 0 -1 0
